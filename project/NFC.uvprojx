# Keil uVision project NFC.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x0000FC00) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: coffee +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\project;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\inc;..\Library\CMSIS;..\Library\STM32F0xx_StdPeriph_Driver\inc;..\Library\STM32F0xx_StdPeriph_Driver\src;..\Library\CMSIS\Device\ST\STM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xb000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c startup_stm32f030.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group library
    ../SYSTEM/usart/: usart.c
    ../Library/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group hardware
    ../HARDWARE/src/: curve_display.c dwin_uart.c heater_control.c pid_controller.c temperature_sensor.c gpio_ctrl.c ac_pump.c pressure_sensor.c encoder.c boiler.c steam.c language.c outlet_temp_sensor.c key_monitor.c water_level.c steam_heater.c settings.c light_pwm.c cmd_console.c brew_heater.c preset_defaults.c preset_store.c flash_op.c
software components: CMSIS:CORE 5.0.1
